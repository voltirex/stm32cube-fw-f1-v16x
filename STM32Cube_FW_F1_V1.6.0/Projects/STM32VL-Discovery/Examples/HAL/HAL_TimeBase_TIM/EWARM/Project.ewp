# IAR project Project.ewp, settings and files
configuration STM32VL-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100VB ST STM32F100VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB; USE_STM32VL_DISCO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32VL-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32VL_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f100xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32VL-Discovery
    ../../../../../../Drivers/BSP/STM32VL-Discovery/: stm32vl_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Example/EWARM
    ./: startup_stm32f100xb.s
  group Example/User
    ../Src/: main.c stm32f1xx_it.c
    ../../../../../STM3210C_EVAL/Examples/HAL/HAL_TimeBase_TIM/Src/: stm32f1xx_hal_timebase_tim.c
