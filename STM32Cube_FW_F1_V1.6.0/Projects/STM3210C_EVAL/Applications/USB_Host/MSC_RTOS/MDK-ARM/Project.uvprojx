# Keil uVision project Project.uvprojx, settings and files
target STM3210C_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3210C_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC,USE_STM3210C_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/STM3210C_EVAL;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Utilities/Log;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210C_EVAL
    ../../../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval.c stm3210c_eval_io.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c list.c tasks.c queue.c
  group Application/User
    ../Src/: file_operations.c usbh_diskio.c explorer.c menu.c stm32f1xx_it.c usbh_conf.c main.c stm32f1xx_hal_timebase_tim.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_ctlreq.c usbh_pipes.c
software components: CMSIS:CORE 4.3.0
