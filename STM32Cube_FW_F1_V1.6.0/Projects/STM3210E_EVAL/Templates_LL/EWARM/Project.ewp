# IAR project Project.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZG ST STM32F103ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xG; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f103xg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32f1xx_LL_Driver
    ../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32f103xg.s
  group Example/User
    ../Src/: main.c stm32f1xx_it.c
